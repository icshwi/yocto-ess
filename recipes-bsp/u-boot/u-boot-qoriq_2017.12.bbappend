FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += "file://0001-Add-support-for-IOxOS-IFC1410.patch \
"
