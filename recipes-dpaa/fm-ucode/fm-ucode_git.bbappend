REGLEX = "t2080"

