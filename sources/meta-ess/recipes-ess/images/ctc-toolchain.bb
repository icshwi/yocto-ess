require recipes-core/meta/meta-toolchain.bb

