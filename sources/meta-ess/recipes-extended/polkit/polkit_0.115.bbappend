FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-pkexec-local-privilege-escalation-CVE-2021-4034.patch"
