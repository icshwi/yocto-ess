pkg_postinst_udev-hwdb () {
	exit 0
}
