SRC_URI = "git://salsa.debian.org/debian/ifenslave.git;protocol=https"
